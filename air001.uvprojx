# Keil uVision project air001.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: air001
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AIR001_DEV
  c include: .\AIR001xx_HAL_Driver\Inc\Legacy;.\AIR001xx_HAL_Driver\Inc;.\other_Driver;.\AIR001xx_HAL_Driver\Inc;.\AIR001xx_HAL_Driver\Src;G:\air001
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./: main.c st7735.c st7735.h spi.c main.h spi.h gpio.c gpio.h font.h
    ./other_Driver/: air001xx_it.c
  group HAL
    ./AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_gpio.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_flash.c air001xx_hal_spi.c air001xx_hal_spi_ex.c air001xx_ll_spi.c air001xx_hal_dma.c air001xx_hal_cortex.c air001xx_hal_adc.c air001xx_hal_adc_ex.c air001xx_hal_exti.c air001xx_hal_tim.c air001xx_hal_tim_ex.c
    ./AIR001xx_HAL_Driver/Inc/: air001xx_hal_spi.h air001xx_hal_spi_ex.h
software components: CMSIS:CORE 5.6.0, Device:Startup 0.0.1
